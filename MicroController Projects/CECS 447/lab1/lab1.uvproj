# Keil uVision project lab1.uvproj, settings and files
target Main (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: lab1
  c flags: Optim=1 uC99=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group lib
    ./: startup.s PLL.c ST7735.c
  group test
    ./: extra.s test.c fixed.c
  group main
    ./: fixed.c lab1.c
target Extra Credit (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: as above
  output: lab1
  c flags: Optim=1 uC99=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
